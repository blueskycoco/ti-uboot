## configs/am335x_sbc8600b_defconfig
```kconfig
CONFIG_SPL=y
CONFIG_SYS_EXTRA_OPTIONS="SBC8600B,NAND"
+S:CONFIG_ARM=y
+S:CONFIG_TARGET_AM335X_EVM=y
```
